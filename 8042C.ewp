# IAR project 8042C.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x30
  ICCAVR.CCDefines: NDEBUG
  postbuild: avrdude -p t2313 -P avrdoper -c stk500v2 -U flash:w:Release\Exe\$PROJ_FNAME$.hex:i -U lfuse:w:0xFF:m -U hfuse:w:0xDB:m -U efuse:w:0xFF:m -U lock:w:0x3C:m
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny2313.xcl
  XLINK.XExtraOptions: -y(CODE)
  group (top)
    ./: lcd_simple.c main.c
